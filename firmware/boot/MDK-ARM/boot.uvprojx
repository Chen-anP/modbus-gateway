# Keil uVision project boot.uvprojx, settings and files
target boot (6240000::V6.24::ARMCLANG)
  device: STM32H563RIVx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ../Core/Inc;../App;../../central/App;../../central/Drivers/STM32H5xx_HAL_Driver/Inc;../../central/Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../central/Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../central/Drivers/CMSIS/Include;../../central/Middlewares/Third_Party/tinyusb/src
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Startup
    ./: startup_stm32h563xx.s
  group Boot/Core
    ../Core/Src/: boot_main.c boot_usb.c boot_log.c boot_it.c system_stm32h5xx.c
  group Boot/App
    ../App/: boot_proto.c app_flash.c
  group Shared (central/App)
    ../../central/App/: mb_rtu.c crc32.c file_rx.c boot_cfg.c flash_if.c usb_descriptors.c boot_guard.c
  group Drivers/HAL
    ../../central/Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_icache.c
  group Middlewares/TinyUSB
    ../../central/Middlewares/Third_Party/tinyusb/src/: tusb.c
    ../../central/Middlewares/Third_Party/tinyusb/src/device/: usbd.c usbd_control.c
    ../../central/Middlewares/Third_Party/tinyusb/src/class/cdc/: cdc_device.c
    ../../central/Middlewares/Third_Party/tinyusb/src/common/: tusb_fifo.c
    ../../central/Middlewares/Third_Party/tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c
